# Repository adenjohns/vision-project

File README.md:

# VISION Project

## Getting started

To make it easy for you to get started with GitLab, here's a list of recommended next steps.

Already a pro? Just edit this README.md and make it your own. Want to make it easy? [Use the template at the bottom](#editing-this-readme)!

## Add your files

- [ ] [Create](https://docs.gitlab.com/ee/user/project/repository/web_editor.html#create-a-file) or [upload](https://docs.gitlab.com/ee/user/project/repository/web_editor.html#upload-a-file) files
- [ ] [Add files using the command line](https://docs.gitlab.com/ee/gitlab-basics/add-file.html#add-a-file-using-the-command-line) or push an existing Git repository with the following command:

```
cd existing_repo
git remote add origin https://git.ucsc.edu/ssinha12/vision-project.git
git branch -M main
git push -uf origin main
```

## Integrate with your tools

- [ ] [Set up project integrations](https://git.ucsc.edu/ssinha12/vision-project/-/settings/integrations)

## Collaborate with your team

- [ ] [Invite team members and collaborators](https://docs.gitlab.com/ee/user/project/members/)
- [ ] [Create a new merge request](https://docs.gitlab.com/ee/user/project/merge_requests/creating_merge_requests.html)
- [ ] [Automatically close issues from merge requests](https://docs.gitlab.com/ee/user/project/issues/managing_issues.html#closing-issues-automatically)
- [ ] [Enable merge request approvals](https://docs.gitlab.com/ee/user/project/merge_requests/approvals/)
- [ ] [Set auto-merge](https://docs.gitlab.com/ee/user/project/merge_requests/merge_when_pipeline_succeeds.html)

## Test and Deploy

Use the built-in continuous integration in GitLab.

- [ ] [Get started with GitLab CI/CD](https://docs.gitlab.com/ee/ci/quick_start/)
- [ ] [Analyze your code for known vulnerabilities with Static Application Security Testing (SAST)](https://docs.gitlab.com/ee/user/application_security/sast/)
- [ ] [Deploy to Kubernetes, Amazon EC2, or Amazon ECS using Auto Deploy](https://docs.gitlab.com/ee/topics/autodevops/requirements.html)
- [ ] [Use pull-based deployments for improved Kubernetes management](https://docs.gitlab.com/ee/user/clusters/agent/)
- [ ] [Set up protected environments](https://docs.gitlab.com/ee/ci/environments/protected_environments.html)

***

# Editing this README

When you're ready to make this README your own, just edit this file and use the handy template below (or feel free to structure it however you want - this is just a starting point!). Thanks to [makeareadme.com](https://www.makeareadme.com/) for this template.

## Suggestions for a good README

Every project is different, so consider which of these sections apply to yours. The sections used in the template are suggestions for most open source projects. Also keep in mind that while a README can be too long and detailed, too long is better than too short. If you think your README is too long, consider utilizing another form of documentation rather than cutting out information.

## Name
Choose a self-explaining name for your project.

## Description
Let people know what your project can do specifically. Provide context and add a link to any reference visitors might be unfamiliar with. A list of Features or a Background subsection can also be added here. If there are alternatives to your project, this is a good place to list differentiating factors.

## Badges
On some READMEs, you may see small images that convey metadata, such as whether or not all the tests are passing for the project. You can use Shields to add some to your README. Many services also have instructions for adding a badge.

## Visuals
Depending on what you are making, it can be a good idea to include screenshots or even a video (you'll frequently see GIFs rather than actual videos). Tools like ttygif can help, but check out Asciinema for a more sophisticated method.

## Installation
Within a particular ecosystem, there may be a common way of installing things, such as using Yarn, NuGet, or Homebrew. However, consider the possibility that whoever is reading your README is a novice and would like more guidance. Listing specific steps helps remove ambiguity and gets people to using your project as quickly as possible. If it only runs in a specific context like a particular programming language version or operating system or has dependencies that have to be installed manually, also add a Requirements subsection.

## Usage
Use examples liberally, and show the expected output if you can. It's helpful to have inline the smallest example of usage that you can demonstrate, while providing links to more sophisticated examples if they are too long to reasonably include in the README.

## Support
Tell people where they can go to for help. It can be any combination of an issue tracker, a chat room, an email address, etc.

## Roadmap
If you have ideas for releases in the future, it is a good idea to list them in the README.

## Contributing
State if you are open to contributions and what your requirements are for accepting them.

For people who want to make changes to your project, it's helpful to have some documentation on how to get started. Perhaps there is a script that they should run or some environment variables that they need to set. Make these steps explicit. These instructions could also be useful to your future self.

You can also document commands to lint the code or run tests. These steps help to ensure high code quality and reduce the likelihood that the changes inadvertently break something. Having instructions for running tests is especially helpful if it requires external setup, such as starting a Selenium server for testing in a browser.

## Authors and acknowledgment
Show your appreciation to those who have contributed to the project.

## License
For open source projects, say how it is licensed.

## Project status
If you have run out of energy or time for your project, put a note at the top of the README saying that development has slowed down or stopped completely. Someone may choose to fork your project or volunteer to step in as a maintainer or owner, allowing your project to keep going. You can also make an explicit request for maintainers.

## KiCad design Power Distribution/OLED/Adafruit 128x32 Pi OLED/Adafruit 128x32 Pi OLED.kicad_pcb

Parts:
C2, C3: 1uF; 0805-NO
C4, C5, C6: 10uF; 0805-NO
FID3, FID4: FIDUCIAL_1MM
IC5: APX803; SOT23
LCD1: OLED 128x32; UG-2832HSWEG02_WRAPUNDER
R2: 10K; 0805-NO
R3: 390K; 0805-NO
RPI1: RASPBERRYPI_2X3; RASPBERRYPI_2X3_THMSMT
U$4: MOUNTINGHOLE3.0THIN; MOUNTINGHOLE_3.0_PLATEDTHIN

Connections:
3.3V: C4.2, IC5.3 (VCC), LCD1.5 (VBAT), LCD1.8 (VDD), R2.2, RPI1.1 (3.3V), RPI1.1' (3.3V)
+5V: RPI1.2 (+5V), RPI1.2' (+5V), RPI1.4 (+5V), RPI1.4' (+5V)
GND: C4.1, C5.1, C6.1, IC5.1 (GND), LCD1.7 (VSS), R3.1, RPI1.6 (GND), RPI1.6' (GND)
unnamed: C2.2, LCD1.1 (C2+)
unnamed: C2.1, LCD1.2 (C2-)
unnamed: C3.2, LCD1.3 (C1+)
unnamed: C3.1, LCD1.4 (C1-)
unnamed: C6.2, LCD1.13 (VCOMH)
unnamed: C5.2, LCD1.14 (VCC)
unnamed: LCD1.12 (IREF), R3.2
SCL: LCD1.10 (SCL), RPI1.5 (SCL), RPI1.5' (SCL)
SDA: LCD1.11 (SDA), RPI1.3 (SDA), RPI1.3' (SDA)
VBREF: LCD1.6 (VBREF)
~OLED_RST: IC5.2 (/RESET), LCD1.9 (RES#), R2.1

Board: 16 copper layers, 20.1 x 34.5 mm, 16 parts (12 on the bottom side), 13 nets.

Other parts of the board:
U$1: ADAFRUIT_2.5MM
U$3: PCBFEAT-REV-040
U$8: ADAFRUIT_TEXT_20MM

## KiCad design Power Distribution/Charging Board/Adafruit PowerBoost 1000C Rev B/Adafruit PowerBoost 1000C Rev B.kicad_pcb

Board: 2 copper layers, 36.1 x 22.9 mm, 47 parts (2 on the bottom side), 23 nets.

Parts:
B1: JST 2-PH; JSTPH2
C1, C7, C8: 10uF; 0805-NO
C2: 2.2uF; 0805-NO
C4: 0.1uF; 0805_10MGAP
C6: 100uF; C1210
CHRG/LBO0: ORANGE; CHIPLED_0805_NOOUTLINE
CN1: USBA_FEMALE; USB_HOST-PTH
CN4: MicroUSB; 4UCONN_20329
DONE0: GREEN; CHIPLED_0805_NOOUTLINE
FID1, FID2, FID3: FIDUCIAL""; FIDUCIAL_1MM
JP2: 1X08_ROUND
L1: 6.8uH; INDUCTOR_5X5MM_TDK_VLC5045
LED1: RED; CHIPLED_0805_NOOUTLINE
LED2: BLUE; CHIPLED_0805_NOOUTLINE
R1: 1.87M; _0805MP
R2: 340K; _0805MP
R3: 1.87M; 0805-NO
R4, R13: 200K; 0805-NO
R5, R8, R14, R20: 1K; 0805-NO
R6: 270K; 0805-NO
R7, R17: 100K; 0805-NO
R9: 43K; 0805-NO
R10: 49.9K; 0805-NO
R11: 75K 1%; 0805-NO
R12: 49.9K 1%; 0805-NO
R16: 1.0K; 0805-NO
T1: MMUN2133LT1G; SC59-BEC
THERM0: 15K; 0805-NO
U1: TPS61090RSAR; PVQFN-16
U2: MCP73871; QFN20_4MM
U$10, U$11: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$12: PCBFEAT-REV-040
U$25: SYMBOL_PLUS
U$26: SYMBOL_MINUS
U$28: ADAFRUIT_5MM
U$45: ADAFRUIT_3.5MM
X1: TERMBLOCK_1X2-3.5MM

Connections:
5.0V: C2.1, C6.1, CN1.VBUS, JP2.8, R3.2, R5.1, R9.2, R11.2, U1.1, U1.15, U1.16, X1.2
D+: CN1.D+, R11.1, R12.1
D-: CN1.D-, R9.1, R10.1
ENABLE: JP2.4, R13.2, U1.11
GND: B1.1, C1.2, C2.2, C4.2, C6.2, C7.2, C8.2, CN1.GND, CN4.BASE@1, CN4.BASE@2, CN4.GND, CN4.SPRT@1, CN4.SPRT@2, CN4.SPRT@3, CN4.SPRT@4, JP2.5, JP2.7, LED1.C, LED2.C, R2.1, R4.1, R7.2, R10.2, R12.2, R16.1, R17.1, THERM0.1, U1.5, U1.6, U1.7, U1.10, U1.13, U1.P$18, U1.P$19, U1.P$20, U1.P$21, U1.P$22, U1.THERMAL, U2.P$10, U2.P$11, U2.P$21, X1.1
LBO: JP2.6, T1.B, U1.12
unnamed: L1.P$2, U1.3, U1.4
unnamed: LED1.A, R20.1
unnamed: R1.1, R2.2, U1.9
unnamed: LED2.A, R5.2
unnamed: R3.1, R4.2, U1.14
unnamed: R20.2, T1.C
unnamed: R6.1, R7.1, U2.P$2
unnamed: DONE0.C, R14.2
unnamed: R14.1, U2.P$7
unnamed: THERM0.2, U2.P$5
unnamed: R8.1, U2.P$8
unnamed: CHRG/LBO0.C, R8.2
unnamed: R17.2, U2.P$12
unnamed: R16.2, U2.P$13
VBAT: C1.1, C4.1, JP2.3, L1.P$1, R1.2, R13.1, T1.E, U1.8, U2.P$1, U2.P$20
VBUS: C8.1, CHRG/LBO0.A, CN4.VBUS, DONE0.A, JP2.1, R6.2, U2.P$3, U2.P$4, U2.P$9, U2.P$17, U2.P$18, U2.P$19
VLIPO: B1.2, C7.1, JP2.2, U2.P$14, U2.P$15, U2.P$16

## Commit log

2025-03-15 Adding symbols and footprint
2025-03-15 adding files
2025-03-17 updated the schematic for PCB
2025-03-17 datasheet
2025-03-20 Updated the PCB schematic
2025-03-20 Footprints and symbol for the raspberry pi
2025-03-23 Add new directory for software
2025-03-23 Add new directory for IMU software
2025-03-23 Software low power standby V1.0, (with new and improved homemade BNO055 library)
2025-03-23 slight changes
2025-03-23 output looks a little better
2025-03-23 PCB in progress
2025-03-23 Updated PCB
2025-03-24 Updated the PCB
2025-03-25 Finish adding the PCM5102a DAC Decoder
2025-03-26 PCB updated
2025-03-27 added the speaker
2025-03-28 fix charging board
2025-03-28 Adding all camera files
2025-03-28 Updating follow_the_gap.py
2025-03-28 First working version of follow_the_gap algorithm on live data
2025-03-28 Made it more compact
2025-03-30 head tracking code
2025-03-30 moving IMUtilt.cpp
2025-03-30 Moving IMUtilt.cpp file
2025-03-30 Edit README.md
2025-03-31 fixed pathing
2025-03-31 Fix circuit pathing
2025-03-31 Refactored follow_the_gap to be in C++
2025-03-31 oled files
2025-03-31 Uploading IMU integration file
2025-03-31 adding IMU integration files
2025-03-31 IMU Integration with camera data
2025-04-03 Cleaning up camera folder files
2025-04-04 adding head tilt code
2025-04-09 modifying path planning and cleaning up files
2025-04-09 added moving average filter
2025-04-14 macking changes to file configs and path planning
2025-04-14 updated arducam readme file
2025-04-15 Path planning can now detect 1, 2, and 0 gaps, moving to IMU code
2025-04-16 oled control python file
2025-04-16 audio feedback state machine version 1.0
2025-04-16 audio feedback state machine version 1.1
2025-04-17 adding object detection code and README files
2025-04-22 edited detection code
2025-04-22 adding code fixes
2025-04-23 adding detection fixes
2025-04-23 adding run script and fixed code
2025-04-24 battery percentage and voltage
2025-04-25 combined audio feedback with preview_depth_IMU
2025-04-26 PCB update
2025-04-26 oled
2025-04-28 adding measurement code, frame skipping
2025-04-28 adding timing and bottleneck identification code
2025-04-28 fixed frame code
2025-04-28 sending over to mac
2025-04-28 adding increased frame skip, smaller input size
2025-04-28 Oled logo
2025-04-28 raspberry pi config file
2025-04-29 adding OpenCL usage
2025-04-29 working config file (fixes display problem)
2025-04-29 adding fixed OpenCL code
2025-04-29 adding motion-based keyframe selection
2025-04-29 adding tweaked motion frame selection
2025-04-29 adding fixed FPS calling
2025-04-29 optimized motion frame selection
2025-04-29 revamed FPS calculation
2025-04-29 finish with the oled
2025-04-29 adding fixed motion frame selection code
2025-04-29 update preview_depth_IMU
2025-04-30 updated preview_depth_IMU
2025-04-30 working preview_depth_IMU
2025-04-30 added command for camera (mandatory)
2025-04-30 adding integration files
2025-04-30 adding last files
2025-05-07 updated schematic and PCB
2025-05-07 Working on camera integration
2025-05-09 adding content keyframe selection
2025-05-13 converted audio from PWM to I2S (version 1.0)
2025-05-13 finishing commit
2025-05-14 content frame tweaks
2025-05-14 updated motion code
2025-05-17 integrated I2S audio code into the main preview_depth_IMU file
2025-05-19 code point
2025-05-19 object tracking
2025-05-19 easier object bounding box data
2025-05-22 tuning object detection preprocessing
2025-05-22 fixed fps code
2025-05-22 adding detection coordinates
2025-05-28 further optimizations
2025-05-31 restored integ file
2025-05-31 restored changes to cmakelists.txt
2025-06-04 updated preview_depth
